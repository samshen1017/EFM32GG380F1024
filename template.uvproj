# Keil uVision project template.uvproj, settings and files
target rtthread-efm3 (ARM-ADS)
  device: EFM32GG380F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: rtthread-efm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
